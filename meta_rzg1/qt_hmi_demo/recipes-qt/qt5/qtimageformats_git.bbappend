#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "3cb878428f1e98578cf027f3b70e9d0b85dcd658"

