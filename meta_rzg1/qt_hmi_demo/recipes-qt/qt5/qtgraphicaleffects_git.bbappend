#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "bfbe2aa4d7b27dfddb19f0905fd3db8ea2c87426"


