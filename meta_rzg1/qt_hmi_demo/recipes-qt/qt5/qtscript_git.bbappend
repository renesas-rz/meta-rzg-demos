#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "f5943eeececd96420a4e9b43ed13e8c12b1b8950"

