#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "a98d1664346481da797c1fab8a4ea34cc92f2887"

