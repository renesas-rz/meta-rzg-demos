#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "0c432de2b560b670f5305f0a86977a9166e74c7b"
