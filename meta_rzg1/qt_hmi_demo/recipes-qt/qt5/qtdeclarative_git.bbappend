#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "f1341bae0ea39d3f5e1c44211c2535e755108748"


