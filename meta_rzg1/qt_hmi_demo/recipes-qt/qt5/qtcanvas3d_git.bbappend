#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "8c35950ce36cd30b5d99abd5ceac052b08c48eec"

