require qt5.6.1_git.inc
SRCREV = "2f94c15099c1ba507bd608293060d979a2b6be52"
