#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "36b36809ff9dc091cf0233f2802d0a32c870081a"

