#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "2a8813edb68ec80bff01a7ca22ff5bbfca1231cf"

