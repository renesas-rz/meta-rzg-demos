#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "384948baa4686f12e36ec3edb37971803b8e715a"

