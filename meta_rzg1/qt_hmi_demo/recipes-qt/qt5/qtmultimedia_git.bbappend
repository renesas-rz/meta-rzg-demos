#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "ffcc913971dae8e49e83d724f4d3f530ef04eb38"

