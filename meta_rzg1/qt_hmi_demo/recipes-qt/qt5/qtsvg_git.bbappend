#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "4a5f9d1f7848869cf25a9574305b9a1c65a7b02a"

