#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "aea3b6885f897f411f27ec79a0696a5fe4cdd2ae"

