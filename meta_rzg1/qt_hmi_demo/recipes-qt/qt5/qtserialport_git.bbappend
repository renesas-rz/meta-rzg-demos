#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "efb42dc6f1d349a15ea85e31e9770034e46bf02e"

