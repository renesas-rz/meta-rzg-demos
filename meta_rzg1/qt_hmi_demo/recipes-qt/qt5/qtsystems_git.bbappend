#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "4566f0ac50e5ea143943c1251028fb01c70289ce"

