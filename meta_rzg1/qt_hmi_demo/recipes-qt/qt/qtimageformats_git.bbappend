
PACKAGECONFIG += "libwebp"
PACKAGECONFIG[libwebp] = ",,"
