FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-mmngr-Add-address-conversion-support-MM_IOC_VTOP.patch"
