# Prepend to force bitbake takes our file first
FILESEXTRAPATHS_prepend := "${THISDIR}/weston-init/:"
FILESEXTRAPATHS_prepend := "${THISDIR}/weston-init/default/:"
FILESEXTRAPATHS_prepend_skrzg1e := "${THISDIR}/weston-init/weston_init_rzg1e/:"
FILESEXTRAPATHS_prepend_skrzg1m := "${THISDIR}/weston-init/weston_init_rzg1m/:"
