FILESEXTRAPATHS_append := "${THISDIR}/mmngr-kernel-module:"
SRC_URI_append = " file://0001_add_physical_address_translate_feature.patch"
