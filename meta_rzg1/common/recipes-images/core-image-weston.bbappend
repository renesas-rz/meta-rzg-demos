
IMAGE_INSTALL_append = " \
  usb-otg-init \
"
