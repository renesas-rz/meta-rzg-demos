PACKAGECONFIG_append = " faad faac "
