FILESEXTRAPATHS_append := "${THISDIR}/qtwayland:"
SRC_URI_append_skrzg1e = " \
    file://0001-Fix-issue-failed-to-initialize-EGL-display.patch \
"
