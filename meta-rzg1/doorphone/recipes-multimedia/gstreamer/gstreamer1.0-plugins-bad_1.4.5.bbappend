PACKAGECONFIG_append = " opencv "

FILES_${PN}-opencv += "${datadir}/"

