FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PNBLACKLIST[obexftp] = ""
