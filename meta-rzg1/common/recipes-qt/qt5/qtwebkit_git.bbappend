#Remove qtlocation due to license issue
PACKAGECONFIG = "gstreamer qtmultimedia qtsensors qtwebchannel"
