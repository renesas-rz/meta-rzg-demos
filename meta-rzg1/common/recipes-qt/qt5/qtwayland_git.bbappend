FILESEXTRAPATHS_append := "${THISDIR}/qtwayland:"
SRC_URI_append = " \
    file://0001-Fix-issue-failed-to-initialize-EGL-display.patch \
"
