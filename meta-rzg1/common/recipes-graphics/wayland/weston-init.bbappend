FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_rzg1 = " file://weston.ini"
