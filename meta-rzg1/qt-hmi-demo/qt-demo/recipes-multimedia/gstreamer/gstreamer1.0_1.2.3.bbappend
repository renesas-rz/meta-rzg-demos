EXTRA_OECONF += "--with-memory-alignment=pagesize"
