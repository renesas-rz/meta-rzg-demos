# Include this make it similar to core-image-weston
include core-image-weston.inc
