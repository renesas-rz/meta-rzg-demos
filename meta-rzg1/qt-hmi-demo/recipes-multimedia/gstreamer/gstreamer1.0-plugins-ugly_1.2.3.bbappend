PACKAGECONFIG_append = " a52dec lame mad mpeg2dec "
