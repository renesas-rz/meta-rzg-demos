PACKAGECONFIG_append = " audioparsers "
