# Prepend to force bitbake takes our file first
FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"
FILESEXTRAPATHS_prepend := "${THISDIR}/files/default/:"
