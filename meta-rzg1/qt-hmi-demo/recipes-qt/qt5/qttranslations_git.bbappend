#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "e6da8d0b4b812674abefd1f0d784fad34140344a"

