#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "ebdaca8ec42e9e4046578177dd672115315c74f8"

