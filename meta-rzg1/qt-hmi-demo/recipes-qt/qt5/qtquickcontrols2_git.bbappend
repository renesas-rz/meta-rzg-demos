#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "38f9063602bdd2f968486fd8ece9a4afbccee766"

