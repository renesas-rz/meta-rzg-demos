require qt5.6.1_git.inc
#Revision to update qt5.6.1
SRCREV_qtwebengine = "63adf8df463163eb5c9d83157f7ea70f9714490f"
SRCREV_chromium = "781d9ccbdd215ca8ae70f24b694ac8b98b253a43"

