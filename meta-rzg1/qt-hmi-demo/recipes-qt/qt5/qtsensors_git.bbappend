#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "2df8f24cb160e54f5951689a6a3ab520a296815a"
