#Revision to update qt5.6.1
require qt5.6.1_git.inc
SRCREV = "539a7007acfa794076e7b2e8757f4edda9da8ff4"


