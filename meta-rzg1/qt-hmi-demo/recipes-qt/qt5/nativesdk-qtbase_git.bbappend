require qt5.6.1_git.inc
#overide source ref for qt5.6.1
SRCREV = "3938fe8fa82ee7fce0c735b36d9a49aabe91c9be"
