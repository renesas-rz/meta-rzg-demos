FILESEXTRAPATHS_prepend := '${THISDIR}/weston:'

SRC_URI_append = " \
"
