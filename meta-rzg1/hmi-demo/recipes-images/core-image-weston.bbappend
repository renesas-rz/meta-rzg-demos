include core-image-weston.inc

IMAGE_INSTALL_append = " \
    configuration \
    demos \
    launcher-taskbar \
    wireless-firmware \
    demo-videos \
"
